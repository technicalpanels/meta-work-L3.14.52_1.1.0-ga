KERNEL_DEVICETREE = "mx6ul-eisd.dtb"
