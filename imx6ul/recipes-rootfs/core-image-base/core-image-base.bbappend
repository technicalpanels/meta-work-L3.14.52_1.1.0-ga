KERNEL_DEVICETREE = "mx6ulipc.dtb mx6ulipc-1g.dtb"
