#SRCBRANCH = 'imx6d'
#SRCREV = '5f4803a89e8c44f2b8305f8ab2415e9188d7eddc'
